# Keil uVision project MainBoard.uvprojx, settings and files
target MainBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MainBoard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c include: .\src;.\src\cmsis;.\src\global_macros;.\src\mcu_support_package\inc;.\src\mcu_support_package;.\src\retarget;.\src\soft_i2c;.\src\spl;.\src\spl\inc;.\src\time_service;.\src\uart;.\src\motors
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/main/: main.cpp
    ./src/: project_config.h pins.h
  group cmsis
    ./src/cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h tz_context.h
  group spl
    ./src/spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uart
    ./src/uart/: i_serial_port.h uart_handle.cpp uart_handle.h uart_handle_mock.h uart_settings.h
  group global_macros
    ./src/global_macros/: global_macros.h qt_global_macros.h stm32f1xx_global_macros.h stm32f3xx_global_macros.h stm32f4xx_global_macros.h stm32lxx_global_macros.h
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f4xx.c
    ./src/mcu_support_package/arm/: startup_stm32f407xx.s
  group time_service
    ./src/time_service/: time_service.cpp time_service.h
  group retarget
    ./src/retarget/: retarget.cpp
  group motors
    ./src/motors/: motors.cpp motors.h
